<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-2-2.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="33022ff3-f082-4548-ab3c-90793765f2d3">
      <SHORT-NAME>AURIX2G</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="7e118c10-0a18-49f2-9978-33759fe5e7c2">
          <SHORT-NAME>EcucDefs</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="dc9e2cbb-b197-46a4-8820-ae7f14e8d55d">
              <SHORT-NAME>Fls_ib_bswmd</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="abe61874-90a7-4ce9-bbc3-682aa6bf29bd">
                  <SHORT-NAME>BswModuleDescriptions</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
